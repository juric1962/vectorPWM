# IAR project vectorPWM.ewp, settings and files
configuration vectorPWM Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405VG ST STM32F405VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F417xx
  ICCARM.IExtraOptions: --diag_suppress Pa082
  ICCARM.CCIncludePath2: ..\Inc; ..\Src\sim; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\STM32F4xx_StdPeriph_Driver\inc; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vectorPWM.hex
  ILINK.IlinkOutputFile: vectorPWM Configuration.out
  ILINK.IlinkIcfFile: F:\почта\UD\CHREP_V3_2\EWARM\stm32f417xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f417xx.s
  group Application/User
    ../Src/: alarms.c archive.c bvi.c DS18B20.c dynaGram.c fram.c InitParam.c InitParam.h main.c modbus.c pwm.c read_write.c scenario_softAP.c sram_rtc.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c utils.c
  group Application/User/Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User/Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Application/User/Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/User/sim800
    ../Src/sim/: Appl_sec.c at_com4.c base1.c coder.c def_at.h def_conf.h def_link.h def_log.h def_prot.h dfcnst.h dfproc.h fppp3.c fram1.c init_pin_sim.c interr4.c ldterm_stm.c ledmd.c logs.c map_ad.h map_ef.h map_mbus.h ozu_map.h pins_stm.c prepare_sim800.c sec.h spvisor.c
