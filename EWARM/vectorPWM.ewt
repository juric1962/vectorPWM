<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>vectorPWM Configuration</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f417xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <group>
        <name>Drivers</name>
        <group>
          <name>CMSIS</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
          </file>
        </group>
        <group>
          <name>STM32F4xx_HAL_Driver</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_usb.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>Middlewares</name>
        <group>
          <name>USB_Device_Library</name>
          <file>
            <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src\usbd_cdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ctlreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ioreq.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>sim800</name>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\Appl_sec.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\at_com4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\base1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\coder.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\def_at.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\def_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\def_link.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\def_log.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\def_prot.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\dfcnst.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\dfproc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\fppp3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\fram1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\init_pin_sim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\interr4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\ldterm_stm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\ledmd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\logs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\map_ad.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\map_ef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\map_mbus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\ozu_map.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\pins_stm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\prepare_sim800.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\sec.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\sim\spvisor.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Src\alarms.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\archive.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\bvi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\DS18B20.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\dynaGram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\fram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\InitParam.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\InitParam.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\modbus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\read_write.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\scenario_softAP.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sram_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usb_device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_cdc_if.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_conf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\utils.c</name>
      </file>
    </group>
  </group>
</project>


